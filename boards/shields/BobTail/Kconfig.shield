## boards/shields/BobTail/Kconfig.shield
```kconfig
config SHIELD_ROBA_R
    def_bool $(shields_list_contains,BobTail_R)

config SHIELD_ROBA_L
    def_bool $(shields_list_contains,BobTail_L)
```
